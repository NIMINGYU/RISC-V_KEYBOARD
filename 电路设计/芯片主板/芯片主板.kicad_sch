File: 电路设计/芯片主板/芯片主板.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: update
Parts:
- added U1: ${MANUFACTURER PART}, symbol 1_P1.schdoc-altium-import:root_0_CH32V307RCT6_
